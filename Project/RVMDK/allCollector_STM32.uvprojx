# Keil uVision project allCollector_STM32.uvprojx, settings and files
target allCollector (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PowerIO_V1.00.00 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Key;..\..\User\LED;..\..\User\motor;..\..\User\SysTick;..\..\User\usart;..\..\User\message_handle;..\..\User\debug;..\..\User\sys;..\..\User\spi;..\..\User\iic;..\..\User\modbus_client;..\..\User\params;..\..\User\dido;..\..\User\modbus_server
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_cl.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c stm32f10x.h system_stm32f10x.c core_cm3.h system_stm32f10x.h
  group FWLIB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: init.c main.c stm32f10x_conf.h time.c stm32f10x_it.c usart_driver.c
    ../../User/LED/: bsp_led.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/message_handle/: message_handle.c
    ../../User/usart/: bsp_usart1.c bsp_usart2.c bsp_usart4.c bsp_usart5.c
    ../../User/debug/: debug.c
    ../../User/sys/: sys.c
    ../../User/spi/: spi.c w25qxx.c
    ../../User/iic/: myiic.c
    ../../User/modbus_client/: modbus.c modbus_rtu.c registers.c
    ../../User/params/: exmath.c params.c
    ../../User/dido/: do.c di.c
    ../../User/Key/: bsp_key.c
  group DOC
    ../../Doc/: readme.txt
